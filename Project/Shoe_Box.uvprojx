# Keil uVision project Shoe_Box.uvprojx, settings and files
target shoe_box (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFTLCD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FW_LIB\F10x_FWLIB\inc;..\APP;..\BSP\inc;..\EDP;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\MALLOC;..\EMWIN\Demo;..\RT-Thread\include;..\RT-Thread;..\RT-Thread\DeviceDrivers\inc;..\RT-Thread\DeviceDrivers;..\NET\device\inc;..\NET\protocol\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group config
    ../APP/: stm32f10x_conf.h
    ../RT-Thread/: rtconfig.h
  group APP
    ../APP/: startup.c application.c
  group BSP
    ../BSP/src/: board.c selfcheck.c led.c dht11.c gy_906.c ili9341_lcd.c xpt2046.c buzzer.c timer.c usart1.c relay.c eeprom.c iic.c
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.h GUIConf.c GUI_X_Touch_Analog.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_RT_thread.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_OS_Keil.lib
  group F10x_FWLIB
    ../FW_LIB/F10x_FWLIB/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group core_cm3
    ../APP/: stm32f10x_it.c
    ../FW_LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
  group RT-Thread
    ../RT-Thread/kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Cortex-M3
    ../RT-Thread/Cortex-M3/: context_rvds.S cpuport.c
  group EDP
    ../EDP/: cJSON.c EdpKit.c
  group MALLOC
    ../MALLOC/: malloc.c
  group EMWIN_Demo
    ../EMWIN/Demo/: test.c GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group NET_Device
    ../NET/device/src/: net_device.c net_io.c
  group NET_protocol
    ../NET/protocol/src/: fault.c onenet.c
  group DOC
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
